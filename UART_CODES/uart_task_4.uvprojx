# Keil uVision project uart_task_4.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart_task_4
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: code_4.c
